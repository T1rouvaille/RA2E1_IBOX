# Keil uVision project ABS_Bootloader.uvprojx, settings and files
target CMS32M5536_Boot (6090000::V6.9::.\ARMCLANG)
  device: CMS32M5536 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ABS_Bootloader +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\2_User;.\1_Device;.\3_driver;..\ABS_Bootloader
  memory RVCT4: ROM 0x0 size 0xdf0
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user_s
    ./2_User/: main.c mcu_config.c cm_handler.c user_fmc.c
  group user_h
    ./2_User/: main.h mcu_config.h cm_handler.h user_fmc.h code_config.h
  group device
    ./1_Device/: cms32m5xxx.h CMSIS_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h startup_cms32m5xxx.s system_cms32m5xxx.c system_cms32m5xxx.h cmsis_armcc_V6.h
  group HAL_CMS32
    ./3_driver/: gpio.h system.h timer.h uart.h
